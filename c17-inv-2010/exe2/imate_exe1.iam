# Autodesk Inventor assembly: imate_exe1
## iProperties
Created: 2008-06
Part Number: imate_exe1
Document SubType Name: Assembly
Designer: CADCIM
Author: CADCIM

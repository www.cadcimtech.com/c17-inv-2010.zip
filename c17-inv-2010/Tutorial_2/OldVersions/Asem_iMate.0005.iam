# Autodesk Inventor assembly: Asem_iMate
## iProperties
Created: 2008-06
Part Number: Asem_iMate
Document SubType Name: Assembly
Designer: CADCIM
Author: CADCIM

# Autodesk Inventor assembly: Tuto_2_Assemb
## iProperties
Created: 2008-06
Part Number: Tuto_2_Assemb
Document SubType Name: Assembly
Designer: CADCIM
Author: CADCIM

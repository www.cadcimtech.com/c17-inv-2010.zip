# Autodesk Inventor assembly: iMate_assembly
## iProperties
Created: 2008-06
Part Number: iMate_assembly
Document SubType Name: Assembly
Designer: CADCIM
Author: CADCIM

# Autodesk Inventor assembly: Assembly_T2
## iProperties
Created: 2008-06
Part Number: Assembly_T2
Document SubType Name: Assembly
Designer: CADCIM
Author: CADCIM

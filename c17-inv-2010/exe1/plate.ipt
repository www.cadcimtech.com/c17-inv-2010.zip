# Autodesk Inventor part: plate
## iProperties
Created: 2008-06
Part Number: plate
Document SubType Name: Modeling
Designer: CADCIM
Density: 1 g/cm^3
Author: CADCIM
## Feature names
1. Extrusion1
